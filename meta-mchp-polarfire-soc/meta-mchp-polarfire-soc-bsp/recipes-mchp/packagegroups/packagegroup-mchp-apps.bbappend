RDEPENDS:packagegroup-mchp-apps:append:mpfs-icicle-kit-all = "\
    polarfire-soc-linux-examples-can \
    polarfire-soc-linux-examples-dma \
    polarfire-soc-linux-examples-dt-overlays \
    polarfire-soc-linux-examples-gateware \
    polarfire-soc-linux-examples-lsram \
    polarfire-soc-linux-examples-pdma \
    polarfire-soc-linux-examples-system-services \
"

RDEPENDS:packagegroup-mchp-apps:append:mpfs-icicle-kit-amp = "\
    kernel-module-rpmsg-char \
    kernel-module-rpmsg-client-sample \
    kernel-module-rpmsg-ctrl \
    kernel-module-rpmsg-tty \
    polarfire-soc-amp-examples \
    polarfire-soc-linux-examples-amp \
"

RDEPENDS:packagegroup-mchp-apps:append:mpfs-video-kit = "\
    polarfire-soc-linux-examples-dt-overlays \
"

RDEPENDS:packagegroup-mchp-apps:append:mpfs-disco-kit = "\
    polarfire-soc-linux-examples-dma \
    polarfire-soc-linux-examples-dt-overlays \
    polarfire-soc-linux-examples-lsram \
    polarfire-soc-linux-examples-pdma \
    polarfire-soc-linux-examples-system-services \
"
