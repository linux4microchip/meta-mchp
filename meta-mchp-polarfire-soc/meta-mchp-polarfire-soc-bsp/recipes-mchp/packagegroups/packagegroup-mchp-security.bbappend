RDEPENDS:packagegroup-mchp-security:mpfs:append = "\
    cryptodev-module \
    openssl-engines \
"
