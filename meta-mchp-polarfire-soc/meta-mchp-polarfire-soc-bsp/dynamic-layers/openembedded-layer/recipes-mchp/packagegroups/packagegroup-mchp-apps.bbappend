RDEPENDS:packagegroup-mchp-apps:append:mpfs-icicle-kit = "\
    polarfire-soc-linux-examples-gpio \
"

RDEPENDS:packagegroup-mchp-apps-amp:append:mpfs-icicle-kit-amp = "\
    polarfire-soc-linux-examples-gpio \
"
