RDEPENDS:packagegroup-mchp-security:mpfs:append = "\
    libkcapi \
"
