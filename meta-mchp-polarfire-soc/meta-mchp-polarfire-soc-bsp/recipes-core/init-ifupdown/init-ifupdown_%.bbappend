FILESEXTRAPATHS:prepend:mpfs := "${THISDIR}/${PN}:"

SRC_URI:append:mpfs = " file://interfaces"
