
RDEPENDS:packagegroup-mchp-apps:append:beaglev-fire = " \
    polarfire-soc-linux-examples-gateware \
"
