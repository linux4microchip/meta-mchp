SRC_URI:append:sama5d2-xplained-optee-sd = " file://0001-ARM-dts-at91-sama5d2_xplained-Fix-memory-when-OP-TEE.patch"
