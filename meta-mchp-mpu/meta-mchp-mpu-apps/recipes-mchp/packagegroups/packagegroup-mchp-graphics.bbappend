RDEPENDS:packagegroup-mchp-graphics:append:sama7d65 = " libm2d"
