SUMMARY = "Image for network/communication and image/video capture"
DESCRIPTION = "An image for network/communication and image/video capture."
LICENSE = "MIT"
PR = "r1"

require mchp-headless-image.inc
