RDEPENDS:packagegroup-mchp-security:append:mpuall = "\
    cryptoauthlib \
    python3-cryptoauthlib \
"
