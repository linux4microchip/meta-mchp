RDEPENDS:packagegroup-mchp-apps:append:pic64gx-curiosity-kit = " \
    pic64gx-linux-examples-dt-overlays \
"

RDEPENDS:packagegroup-mchp-apps:append:pic64gx-curiosity-kit-amp = " \
    pic64gx-linux-examples-amp \
    pic64gx-linux-examples-dt-overlays \
"
