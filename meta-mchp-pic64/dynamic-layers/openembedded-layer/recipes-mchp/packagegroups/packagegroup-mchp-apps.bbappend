RDEPENDS:packagegroup-mchp-apps:append:pic64gx-curiosity-kit = " \
    pic64gx-linux-examples-multimedia \
"


