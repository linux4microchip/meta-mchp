RDEPENDS:packagegroup-mchp-apps-amp:append:pic64gx-curiosity-kit-amp = " pic64gx-zephyr-amp-demo pic64gx-zephyr-amp-demo-hss"
