PACKAGES =+ "${PN}-systemd"
FILES:${PN}-systemd = "${sysconfdir}/cpupower-service.conf ${systemd_unitdir}"
