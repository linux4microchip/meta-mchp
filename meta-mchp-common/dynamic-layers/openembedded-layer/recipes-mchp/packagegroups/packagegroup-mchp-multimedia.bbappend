PACKAGES += "packagegroup-mchp-multimedia-camera"
RDEPENDS:packagegroup-mchp-multimedia-camera = "\
    fswebcam \
    libcamera-mchp \
    libcamera-mchp-apps \
    libv4l \
    media-ctl \
    v4l-utils \
    yavta \
"
