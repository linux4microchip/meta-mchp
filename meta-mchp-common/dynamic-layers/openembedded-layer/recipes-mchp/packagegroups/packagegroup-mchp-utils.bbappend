RDEPENDS:packagegroup-mchp-system-utils += "\
    cpupower \
    evtest \
"

RDEPENDS:packagegroup-mchp-hw-utils += "\
    can-utils \
    devmem2 \
    libgpiod-tools \
"

RDEPENDS:packagegroup-mchp-user-utils += "\
    nano \
"

RDEPENDS:packagegroup-mchp-benchmark-utils += "\
    bonnie++ \
    iozone3 \
    lmbench \
    nbench-byte \
"
