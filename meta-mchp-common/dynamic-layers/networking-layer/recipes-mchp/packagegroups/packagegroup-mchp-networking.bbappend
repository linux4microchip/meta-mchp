
RDEPENDS:packagegroup-mchp-networking += "\
    bridge-utils \
    linuxptp \
    netcat \
    nftables \
    phytool \
    tcpdump \
"
