SUMMARY = "Base image with Microchip apps and utilities"
DESCRIPTION = "Base image with Microchip apps, networking, security, and utilities."
LICENSE = "MIT"

require mchp-base-image.inc
