require linux.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

LINUX_VERSION = "6.18.54"
KBRANCH = "linux-6.18-mchp"
SRCREV = "67291e4c8d402f37a4f9e92a029d150f0c432380"
